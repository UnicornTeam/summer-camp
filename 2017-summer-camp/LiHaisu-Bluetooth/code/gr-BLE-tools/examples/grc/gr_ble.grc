<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_ble</value></param>
<param><key>author</key><value>backahasten</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Bluetooth LE Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>accaddr</value></param>
<param><key>value</key><value>int("0x8E89BED6",16)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ble_base_freq</value></param>
<param><key>value</key><value>2402e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ble_channel_spacing</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_freq</value></param>
<param><key>value</key><value>850e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dv_channel</value></param>
<param><key>value</key><value>37</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>ble_base_freq+(ble_channel_spacing * rf_channel)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_gain_mu</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_mu</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_omega_limit</value></param>
<param><key>value</key><value>0.035</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmsk_sps</value></param>
<param><key>value</key><value>int(sample_rate / data_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lowpass_filter</value></param>
<param><key>value</key><value>firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_channel</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_threshold</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>-100</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>num_steps</key><value>1</value></param>
<param><key>style</key><value>wx.SL_VERTICAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_width</value></param>
<param><key>value</key><value>300e3</value></param>
</block>
<block>
<key>BLE_tools_BLE_debugsink</key>
<param><key>id</key><value>BLE_tools_BLE_debugsink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>accaddr</key><value>str(hex(accaddr))[2:]</value></param>
<param><key>channel</key><value>dv_channel</value></param>
</block>
<block>
<key>BLE_tools_BLE_pack_collect</key>
<param><key>id</key><value>BLE_tools_BLE_pack_collect_0</value></param>
<param><key>accaddr</key><value>str(hex(accaddr))[2:]</value></param>
<param><key>channel</key><value>dv_channel</value></param>
</block>
<block>
<key>BLE_tools_find_pack_by_preamble</key>
<param><key>id</key><value>BLE_tools_find_pack_by_preamble_0</value></param>
</block>
<block>
<key>BLE_tools_pack_bin_to_byte</key>
<param><key>id</key><value>BLE_tools_pack_bin_to_byte_0</value></param>
<param><key>fill</key><value>0</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>threshold</key><value>-350</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>digital_gfsk_demod</key>
<param><key>id</key><value>digital_gfsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>int(sample_rate/1e6)</value></param>
<param><key>sensitivity</key><value>(3.1415926 / 2) / (sample_rate/1e6)</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_lp</value></param>
<param><key>center_freq</key><value>-freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>taps</key><value>lowpass_filter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq+freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://*:23333</value></param>
<param><key>timeout</key><value>0</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>tcp://*:23333</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>0</value></param>
</block>
<connection><source_block_id>BLE_tools_BLE_debugsink_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>BLE_tools_BLE_pack_collect_0</source_block_id><sink_block_id>BLE_tools_pack_bin_to_byte_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>BLE_tools_find_pack_by_preamble_0</source_block_id><sink_block_id>BLE_tools_BLE_debugsink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>BLE_tools_find_pack_by_preamble_0</source_block_id><sink_block_id>BLE_tools_BLE_pack_collect_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>BLE_tools_find_pack_by_preamble_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>BLE_tools_find_pack_by_preamble_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>BLE_tools_pack_bin_to_byte_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>analog_simple_squelch</source_block_id><sink_block_id>freq_xlating_fir_filter_lp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gfsk_demod_0</source_block_id><sink_block_id>BLE_tools_find_pack_by_preamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_lp</source_block_id><sink_block_id>digital_gfsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_lp</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source</source_block_id><sink_block_id>analog_simple_squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
